# Keil uVision project Blink.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Blink
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F4XX,HSE_VALUE=8000000
  c include: ..\Blink_Project;.\src;.\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: main.c
  group src
    ./: app.c
  group inc
    ./: app.h
software components: CMSIS:CORE 5.3.0, Device:STM32Cube Framework:Classic 1.7.13, Device:STM32Cube HAL:Common 1.7.13, Device:STM32Cube HAL:Cortex 1.7.13, Device:STM32Cube HAL:GPIO 1.7.13, Device:STM32Cube HAL:PWR 1.7.13, Device:STM32Cube HAL:RCC 1.7.13, Device:STM32Cube LL:Common 1.7.13, Device:STM32Cube LL:GPIO 1.7.13, Device:STM32Cube LL:LPTIM 1.7.13, Device:STM32Cube LL:PWR 1.7.13, Device:STM32Cube LL:RCC 1.7.13, Device:STM32Cube LL:SPI 1.7.13, Device:STM32Cube LL:UTILS 1.7.13, Device:Startup 2.6.3
